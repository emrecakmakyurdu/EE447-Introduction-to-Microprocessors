# Keil uVision project project.uvprojx, settings and files
target Target 1 (6140000::V6.14::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: Startup.s main.s POT_GPIO_INIT.s POT_ADC_INIT.s SWITCH_INIT.s POT_ADC.s DELAY100.s DIST_EDGE_INIT.s DIST_PULSE_INIT.s DISTANCE.s MOTOR_GPIO_INIT.s MOTOR_GPTM_INIT.s MOTOR_GPTM_ISR.s SCREEN.s KEYPAD.s KEYPAD_INIT.s littledelay.s SCREEN_INIT.s SCREEN_FUNC.s
