			AREA subroutine,	READONLY,	CODE
			THUMB
			EXTERN	RECURSION
			EXPORT	FourthRule
				
ADRES		EQU		0X20000000
				
FourthRule

			PUSH	{R0,LR}
			
			MOV		R1,#9			;9'DAN KUCUK MU
			CMP		R0,R1
			BLS		JUMP			;KUCUKSE CIK
			
			MOV		R1,#3			;3'E BOLUNEBILIYOR MU
			UDIV	R2,R0,R1
			MUL		R2,R2,R1
			CMP		R0,R2
			BNE		JUMP			; BOLUNEMIYORSA CIK
			
			
			PUSH	{R0}
			MOV		R1,#10
			LDR		R5,=ADRES
LOOP		UDIV	R2,R0,R1		; BASAMAKLARI BULAN KOD
			MUL		R2,R2,R1
			SUB		R2,R0,R2		; DIGIT ON THE RIGHTMOST
			STRB	R2,[R5],#1
			UDIV	R0,R0,R1		; SHIFT THE NUMBER
			CMP		R0,#0			; SAYI 0 OLMADIYSA DEVAM
			BNE		LOOP
			
			;SUB		R5,#1			; BACK 1 BYTE
			LDR		R6,=ADRES
			MOV		R1,#1			; BASAMAKLARI CARPIMI R1'DE SAKLANIYOR
LOOP2		LDRB	R2,[R6],#1
			CMP		R2,#4
			MULNE	R1,R2			;R1 BASAMAK CARPIMLARI OLDU
			CMP		R5,R6
			BNE		LOOP2
			
			POP		{R0}
			CMP		R1,#0
			BEQ		JUMP
			SUB		R0,R1
			BL		RECURSION
JUMP		POP		{R0,LR}
			BX		LR
			ALIGN
			END