			AREA subroutine,	READONLY,	CODE
			THUMB
			EXTERN	MYPARCEL
			EXPORT	ThirdArea
				
ThirdArea

			PUSH	{R0,LR}
			MOV		R1,#530			;530'DAN BUYUK MU
			CMP		R0,R1
			BHI		JUMP			;BUYUKSE CIK
			MOV		R1,#4			;4'E BOLUNUR MU
			UDIV	R2,R0,R1
			MUL		R2,R2,R1
			CMP		R0,R2
			BNE		JUMP			;BOLUNMUYORSA CIK
			MOV		R1,#10
			MOV		R4,#0
			PUSH	{R0}
LOOP		UDIV	R2,R0,R1		; BASAMAKLARI TOPLAMI R4'TE SAKLANIYOR
			MUL		R2,R2,R1
			SUB		R2,R0,R2
			ADD		R4,R2
			UDIV	R0,R0,R1
			CMP		R0,#0
			BNE		LOOP
			
			POP		{R0}
			SUB		R0,R4
			BL		MYPARCEL
JUMP		POP		{R0,LR}
			BX		LR
			END