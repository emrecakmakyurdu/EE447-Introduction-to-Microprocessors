FIRST	EQU	0X20000480
	
	AREA	subroutine,	READONLY,	CODE
	THUMB
	EXPORT	CONVRT

;	BU KOD R4'TE VERILEN DEGERI ASCII'YE, BASILABILECEK HALE CEVIRIYOR
;	R4 IS MY NUMBER TO BE CONVERTED TO ASCII
;	R5 HAS THE ADDRESS OF THE MESSAGE
;	IF YOU WANT TO DISPLAY R5, AFTER CALLING THIS FUNCTION, REASSIGN R5 TO THE BEGINNING OF THE MESSAGE
		
CONVRT
	PUSH	{R0-R4}
	MOV		R0,#0XA
	LDR		R3,=FIRST
	
LOOP1					; BASAMAKLARA AYIR
	
	UDIV	R1,R4,R0
	MUL		R1,R1,R0
	SUB		R1,R4,R1
	STRB	R1,[R3],#1
	UDIV	R4,R4,R0
	CMP		R4,#0
	BNE		LOOP1
	
	MOV		R0,#0
	MOV		R1,#0
	LDR		R1,=FIRST
	
LOOP2					;	TRANSLATION AND STORING

	SUB		R3,R3,#1
	LDR		R0,[R3]
	ADD		R0,R0,#48	; TRANSLATE TO ASCII
	STRB	R0,[R5],#1
	CMP		R3,R1
	BNE		LOOP2
	
	
	MOV		R0,#0X0A	; NEW LINE
	STRB	R0,[R5]
	ADD		R5,R5,#1
	MOV		R0,#0X0D
	STRB	R0,[R5]
	ADD		R5,R5,#1
	MOV		R0,#0X04
	STRB	R0,[R5]
	POP		{R0-R4}
	BX		LR
	ALIGN
	END
	